# Keil uVision project 电子指南针.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 电子指南针 +hex
  c flags: Optimize=8 SizeSpeed=1
  group sys
    ./sys/: sys.c sys.h
  group TFT
    ./sys/: led.c led.h
  group QMC
    ./sys/: iic.c iic.h
  group main
    ./: main.c
